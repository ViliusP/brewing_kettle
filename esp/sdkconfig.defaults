## esp/sdkconfig.defaults.esp32c6
```kconfig
CONFIG_BLINK_LED_STRIP=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
CONFIG_LWIP_LOCAL_HOSTNAME="brewkettle_esp32"
```
